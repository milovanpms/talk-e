## software/i2c_oled/main/Kconfig.projbuild
```kconfig
menu "Example Configuration"

    comment "Fixed target: T-Beam 1.3\" OLED (SSD1306 + SH1106-compatible mapping)"

endmenu
```
